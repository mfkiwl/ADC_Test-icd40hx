File: hardware/project/ADC_Test/Ethernet.sch (KiCad schematic (older format))
At the start: 43 parts

Commit message: Development
Parts:
- gave numbers to parts that had none: 43
